require recipes-kernel/ccu-kernel/linux-common-append.inc
